# Keil uVision project NuMaker_TRIO.uvproj, settings and files
target Nuwarocks (ARM-ADS)
  device: NANO102ZC2AN Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\3rdparty\nuvoton\Library\Device\Nuvoton\Nano1X2Series\Include;..\..\..\3rdparty\nuvoton\Library\StdDriver\inc;..\..\..\3rdparty\nuvoton\Library\CMSIS\Include;..\..\..\3rdparty\nuvoton\RAK_Include;..\..\..\3rdparty\nuvoton\RAK_Source;..\..\..\3rdparty\nuvoton;..\..\..\src\platforms\nuvoton;..\..\..\src;..
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_Nano1x2Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../3rdparty/nuvoton/Library/Device/Nuvoton/Nano1X2Series/Source/: system_Nano1X2Series.c
    ../../../3rdparty/nuvoton/Library/Device/Nuvoton/Nano1X2Series/Source/ARM/: startup_Nano1X2Series.s
  group Libraries
    ../../../3rdparty/nuvoton/Library/StdDriver/src/: sys.c clk.c uart.c gpio.c i2c.c rtc.c pwm.c adc.c timer.c
  group RAK_Source
    ../../../3rdparty/nuvoton/RAK_Source/: RAK415.c ringbuff.c
  group RAK_Driver
    ../../../3rdparty/nuvoton/RAK_Driver/: rak_write_userConfig.c rak_config_init.c rak_copy_uConfig.c rak_easy_config.c rak_easy_txrxMode.c rak_get_scan.c rak_query_constatus.c rak_query_fwversion.c rak_query_ipconfig.c rak_query_macaddr.c rak_query_rssi.c rak_query_tcpstatus.c rak_read_restoreConfig.c rak_read_userConfig.c rak_reset.c rak_restore.c rak_scan_ap.c rak_send_data.c rak_wps_config.c rak_write_restoreConfig.c
  group User
    ../: main.c
    ../../../3rdparty/nuvoton/: LM75A.c MPU6050.c LY096BG30.c DHT11.c systimer.c
  group uNabto
    ../: unabto_application.c
    ../../../src/unabto/: unabto_aes128_sha256.c unabto_app_adapter.c unabto_attach.c unabto_buffers.c unabto_common_main.c unabto_connection.c unabto_context.c unabto_crypto.c unabto_debug_packet.c unabto_message.c unabto_nano_stream.c unabto_next_event.c unabto_packet.c unabto_packet_util.c unabto_prf.c unabto_query_rw.c unabto_stream.c unabto_stream_environment.c unabto_stream_event.c unabto_stream_window.c unabto_tcp_fallback.c unabto_extended_rendezvous.c
    ../../../src/platforms/nuvoton/: unabto_platform.c
